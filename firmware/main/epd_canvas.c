#include "epd_canvas.h"

#include <stddef.h>
#include <string.h>

typedef struct {
  char character;
  uint8_t rows[7];
} glyph_t;

static const glyph_t GLYPHS[] = {
    {' ', {0, 0, 0, 0, 0, 0, 0}},
    {'%', {0x19, 0x19, 0x02, 0x04, 0x08, 0x13, 0x13}},
    {'+', {0, 0x04, 0x04, 0x1F, 0x04, 0x04, 0}},
    {'-', {0, 0, 0, 0x1F, 0, 0, 0}},
    {'.', {0, 0, 0, 0, 0, 0x0C, 0x0C}},
    {':', {0, 0x0C, 0x0C, 0, 0x0C, 0x0C, 0}},
    {'0', {0x0E, 0x11, 0x13, 0x15, 0x19, 0x11, 0x0E}},
    {'1', {0x04, 0x0C, 0x14, 0x04, 0x04, 0x04, 0x1F}},
    {'2', {0x0E, 0x11, 0x01, 0x02, 0x04, 0x08, 0x1F}},
    {'3', {0x1E, 0x01, 0x01, 0x0E, 0x01, 0x01, 0x1E}},
    {'4', {0x02, 0x06, 0x0A, 0x12, 0x1F, 0x02, 0x02}},
    {'5', {0x1F, 0x10, 0x10, 0x1E, 0x01, 0x01, 0x1E}},
    {'6', {0x0E, 0x10, 0x10, 0x1E, 0x11, 0x11, 0x0E}},
    {'7', {0x1F, 0x01, 0x02, 0x04, 0x08, 0x08, 0x08}},
    {'8', {0x0E, 0x11, 0x11, 0x0E, 0x11, 0x11, 0x0E}},
    {'9', {0x0E, 0x11, 0x11, 0x0F, 0x01, 0x01, 0x0E}},
    {'A', {0x0E, 0x11, 0x11, 0x1F, 0x11, 0x11, 0x11}},
    {'B', {0x1E, 0x11, 0x11, 0x1E, 0x11, 0x11, 0x1E}},
    {'C', {0x0E, 0x11, 0x10, 0x10, 0x10, 0x11, 0x0E}},
    {'D', {0x1E, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1E}},
    {'E', {0x1F, 0x10, 0x10, 0x1E, 0x10, 0x10, 0x1F}},
    {'F', {0x1F, 0x10, 0x10, 0x1E, 0x10, 0x10, 0x10}},
    {'G', {0x0E, 0x11, 0x10, 0x17, 0x11, 0x11, 0x0F}},
    {'H', {0x11, 0x11, 0x11, 0x1F, 0x11, 0x11, 0x11}},
    {'I', {0x0E, 0x04, 0x04, 0x04, 0x04, 0x04, 0x0E}},
    {'J', {0x07, 0x02, 0x02, 0x02, 0x12, 0x12, 0x0C}},
    {'K', {0x11, 0x12, 0x14, 0x18, 0x14, 0x12, 0x11}},
    {'L', {0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1F}},
    {'M', {0x11, 0x1B, 0x15, 0x15, 0x11, 0x11, 0x11}},
    {'N', {0x11, 0x19, 0x15, 0x13, 0x11, 0x11, 0x11}},
    {'O', {0x0E, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0E}},
    {'P', {0x1E, 0x11, 0x11, 0x1E, 0x10, 0x10, 0x10}},
    {'Q', {0x0E, 0x11, 0x11, 0x11, 0x15, 0x12, 0x0D}},
    {'R', {0x1E, 0x11, 0x11, 0x1E, 0x14, 0x12, 0x11}},
    {'S', {0x0F, 0x10, 0x10, 0x0E, 0x01, 0x01, 0x1E}},
    {'T', {0x1F, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04}},
    {'U', {0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0E}},
    {'V', {0x11, 0x11, 0x11, 0x11, 0x11, 0x0A, 0x04}},
    {'W', {0x11, 0x11, 0x11, 0x15, 0x15, 0x15, 0x0A}},
    {'X', {0x11, 0x11, 0x0A, 0x04, 0x0A, 0x11, 0x11}},
    {'Y', {0x11, 0x11, 0x0A, 0x04, 0x04, 0x04, 0x04}},
    {'Z', {0x1F, 0x01, 0x02, 0x04, 0x08, 0x10, 0x1F}},
};

static const uint8_t *find_glyph(char character) {
  if (character >= 'a' && character <= 'z') {
    character = (char)(character - 'a' + 'A');
  }

  for (size_t i = 0; i < sizeof(GLYPHS) / sizeof(GLYPHS[0]); ++i) {
    if (GLYPHS[i].character == character) {
      return GLYPHS[i].rows;
    }
  }

  return GLYPHS[0].rows;
}

void epd_canvas_clear(epd_canvas_t *canvas, epd_color_t color) {
  uint8_t black = 0xFF;
  uint8_t red = 0xFF;

  if (color == EPD_COLOR_BLACK) {
    black = 0x00;
  } else if (color == EPD_COLOR_RED) {
    red = 0x00;
  }

  memset(canvas->black, black, EPD_CANVAS_BUFFER_SIZE);
  memset(canvas->red, red, EPD_CANVAS_BUFFER_SIZE);
}

void epd_canvas_pixel(epd_canvas_t *canvas, int x, int y, epd_color_t color) {
  if (canvas == NULL || canvas->black == NULL || canvas->red == NULL || x < 0 ||
      x >= BOARD_EPD_WIDTH || y < 0 || y >= BOARD_EPD_HEIGHT) {
    return;
  }

  const size_t index = (size_t)y * (BOARD_EPD_WIDTH / 8) + (size_t)x / 8;
  const uint8_t mask = (uint8_t)(0x80U >> (x & 7));

  if (color == EPD_COLOR_BLACK) {
    canvas->black[index] &= (uint8_t)~mask;
    canvas->red[index] |= mask;
  } else if (color == EPD_COLOR_RED) {
    canvas->black[index] |= mask;
    canvas->red[index] &= (uint8_t)~mask;
  } else {
    canvas->black[index] |= mask;
    canvas->red[index] |= mask;
  }
}

void epd_canvas_fill_rect(epd_canvas_t *canvas, int x, int y, int width,
                          int height, epd_color_t color) {
  for (int row = y; row < y + height; ++row) {
    for (int column = x; column < x + width; ++column) {
      epd_canvas_pixel(canvas, column, row, color);
    }
  }
}

void epd_canvas_draw_text(epd_canvas_t *canvas, int x, int y, const char *text,
                          int scale, epd_color_t color) {
  if (text == NULL || scale <= 0) {
    return;
  }

  for (const char *cursor = text; *cursor != '\0'; ++cursor) {
    const uint8_t *rows = find_glyph(*cursor);
    for (int glyph_y = 0; glyph_y < 7; ++glyph_y) {
      for (int glyph_x = 0; glyph_x < 5; ++glyph_x) {
        if ((rows[glyph_y] & (1U << (4 - glyph_x))) == 0) {
          continue;
        }
        epd_canvas_fill_rect(canvas, x + glyph_x * scale, y + glyph_y * scale,
                             scale, scale, color);
      }
    }
    x += 6 * scale;
  }
}

int epd_canvas_text_width(const char *text, int scale) {
  return text == NULL || scale <= 0 ? 0 : (int)strlen(text) * 6 * scale;
}
